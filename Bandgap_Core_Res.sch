v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
P 4 1 -10 -790 {}
T {Bandgap} 1670 290 0 0 0.4 0.4 {}
T {Bandgap Startup Circuit} 1020 290 0 0 0.4 0.4 {}
T {Bandgap Cascode Reference} 590 290 0 0 0.4 0.4 {}
T {Bandgap Cascode Startup Circuit} 110 290 0 0 0.4 0.4 {}
T {Folded Cascode} 1050 1680 0 0 0.4 0.4 {}
T {Folded Cascode Bias Network} 1810 1050 0 0 0.4 0.4 {}
T {Beta Multiplier IREF} 1110 1050 0 0 0.4 0.4 {}
T {Bandgap Cascode Reference
} 300 1050 0 0 0.4 0.4 {}
T {Startup Circuit} 790 1050 0 0 0.4 0.4 {}
T {Trim Network} 2910 937.5 0 0 0.4 0.4 {}
N 1680 -700 1700 -700 {lab=vgp}
N 1740 -700 1820 -700 {lab=avdd}
N 1820 -760 1820 -700 {lab=avdd}
N 1740 -760 1820 -760 {lab=avdd}
N 1740 -760 1740 -730 {lab=avdd}
N 1450 -700 1530 -700 {lab=avdd}
N 1450 -760 1530 -760 {lab=avdd}
N 1530 -760 1530 -730 {lab=avdd}
N 1450 -760 1450 -700 {lab=avdd}
N 1970 -700 2050 -700 {lab=avdd}
N 1970 -760 2050 -760 {lab=avdd}
N 1610 -130 1610 -70 {lab=vgn1}
N 1740 -500 1860 -500 {lab=vgp}
N 1530 220 1530 250 {lab=avss}
N 1530 250 1740 250 {lab=avss}
N 1740 220 1740 250 {lab=avss}
N 1810 250 1970 250 {lab=avss}
N 1970 220 1970 250 {lab=avss}
N 1780 190 1810 190 {lab=avss}
N 1810 190 1810 250 {lab=avss}
N 1470 250 1530 250 {lab=avss}
N 1470 190 1470 250 {lab=avss}
N 1470 190 1490 190 {lab=avss}
N 1970 250 2040 250 {lab=avss}
N 2040 190 2040 250 {lab=avss}
N 2010 190 2040 190 {lab=avss}
N 1470 -70 1530 -70 {lab=avss}
N 1740 -70 1810 -70 {lab=avss}
N 1130 -760 1450 -760 {lab=avdd}
N 1130 -760 1130 -720 {lab=avdd}
N 1170 -690 1260 -690 {lab=vgp}
N 1130 -660 1130 -640 {lab=vsu}
N 1260 -690 1390 -690 {lab=vgp}
N 1390 -690 1390 -650 {lab=vgp}
N 1390 -650 1660 -650 {lab=vgp}
N 1050 -10 1090 -10 {lab=vsu}
N 1050 -70 1050 -10 {lab=vsu}
N 1130 -320 1130 -40 {lab=vsu}
N 1050 90 1090 90 {lab=bgsu1}
N 1050 30 1050 90 {lab=bgsu1}
N 1050 30 1130 30 {lab=bgsu1}
N 1130 30 1130 60 {lab=bgsu1}
N 1050 200 1090 200 {lab=bgsu2}
N 1050 140 1050 200 {lab=bgsu2}
N 1050 140 1130 140 {lab=bgsu2}
N 1130 140 1130 170 {lab=bgsu2}
N 1130 230 1130 250 {lab=avss}
N 1230 250 1470 250 {lab=avss}
N 1230 200 1230 250 {lab=avss}
N 1130 200 1230 200 {lab=avss}
N 1130 120 1130 140 {lab=bgsu2}
N 1130 90 1230 90 {lab=avss}
N 1230 90 1230 200 {lab=avss}
N 1230 -10 1230 90 {lab=avss}
N 1130 -10 1230 -10 {lab=avss}
N 1130 -640 1130 -320 {lab=vsu}
N 1530 -760 1740 -760 {lab=avdd}
N 1970 -760 1970 -730 {lab=avdd}
N 1820 -760 1970 -760 {lab=avdd}
N 1050 -690 1130 -690 {lab=avdd}
N 1050 -760 1050 -690 {lab=avdd}
N 1050 -760 1130 -760 {lab=avdd}
N 1740 -40 1740 70 {lab=v2}
N 1740 130 1740 160 {lab=vq2}
N 1970 130 1970 160 {lab=vq3}
N 1680 100 1720 100 {lab=avss}
N 1530 -120 1530 -100 {lab=vgn1}
N 2050 -760 2050 -700 {lab=avdd}
N 1530 -670 1530 -610 {lab=vx1}
N 1450 -580 1530 -580 {lab=avdd}
N 1740 -670 1740 -610 {lab=vx2}
N 1570 -580 1700 -580 {lab=vcasp}
N 1970 -670 1970 -610 {lab=vx3}
N 1970 -580 2050 -580 {lab=avdd}
N 2050 -700 2050 -580 {lab=avdd}
N 1970 -550 1970 -470 {lab=#net1}
N 1740 -500 1740 -470 {lab=vgp}
N 1870 -580 1930 -580 {lab=vcasp}
N 1660 -700 1660 -650 {lab=vgp}
N 1860 -700 1930 -700 {lab=vgp}
N 1860 -700 1860 -500 {lab=vgp}
N 1680 -520 1740 -520 {lab=vgp}
N 1680 -700 1680 -520 {lab=vgp}
N 1740 -580 1800 -580 {lab=avdd}
N 900 250 1130 250 {lab=avss}
N 530 110 530 250 {lab=avss}
N 440 -660 530 -660 {lab=avdd}
N 530 -760 900 -760 {lab=avdd}
N 440 -760 440 -660 {lab=avdd}
N 530 -760 530 -690 {lab=avdd}
N 530 -630 530 -540 {lab=vaux}
N 830 -670 860 -670 {lab=vcasp}
N 830 -670 830 -610 {lab=vcasp}
N 830 -610 900 -610 {lab=vcasp}
N 900 -640 900 -610 {lab=vcasp}
N 900 -760 900 -700 {lab=avdd}
N 980 -760 980 -670 {lab=avdd}
N 900 150 900 250 {lab=avss}
N 900 80 980 80 {lab=avss}
N 980 80 980 150 {lab=avss}
N 900 150 980 150 {lab=avss}
N 900 -610 900 -510 {lab=vcasp}
N 530 -10 650 -10 {lab=vbn}
N 570 -660 640 -660 {lab=vgp}
N 980 -760 1050 -760 {lab=avdd}
N 650 80 860 80 {lab=vbn}
N 1130 20 1130 30 {lab=bgsu1}
N 530 -10 530 50 {lab=vbn}
N 530 -330 530 -10 {lab=vbn}
N 440 -510 530 -510 {lab=avdd}
N 440 -660 440 -510 {lab=avdd}
N 570 -510 900 -510 {lab=vcasp}
N 110 -760 110 -720 {lab=avdd}
N 150 -690 240 -690 {lab=vcasp}
N 110 -660 110 -640 {lab=vsua}
N 30 -10 70 -10 {lab=vsua}
N 30 -70 30 -10 {lab=vsua}
N 110 -320 110 -40 {lab=vsua}
N 30 90 70 90 {lab=auxsu1}
N 30 30 30 90 {lab=auxsu1}
N 30 30 110 30 {lab=auxsu1}
N 110 30 110 60 {lab=auxsu1}
N 30 200 70 200 {lab=auxsu2}
N 30 140 30 200 {lab=auxsu2}
N 30 140 110 140 {lab=auxsu2}
N 110 140 110 170 {lab=auxsu2}
N 210 200 210 250 {lab=avss}
N 110 200 210 200 {lab=avss}
N 110 120 110 140 {lab=auxsu2}
N 110 90 210 90 {lab=avss}
N 210 90 210 200 {lab=avss}
N 210 -10 210 90 {lab=avss}
N 110 -10 210 -10 {lab=avss}
N 110 -640 110 -320 {lab=vsua}
N 30 -690 110 -690 {lab=avdd}
N 30 -760 30 -690 {lab=avdd}
N 110 20 110 30 {lab=auxsu1}
N 110 230 110 250 {lab=avss}
N 210 250 450 250 {lab=avss}
N 310 -760 360 -760 {lab=avdd}
N 570 80 650 80 {lab=vbn}
N 650 -10 650 80 {lab=vbn}
N 470 80 530 80 {lab=avss}
N 530 -480 530 -330 {lab=vbn}
N 900 -510 900 -200 {lab=vcasp}
N 1530 -40 1530 160 {lab=v1}
N 1970 -410 1970 -260 {lab=vref}
N 1570 -70 1610 -70 {lab=vgn1}
N 1650 -70 1700 -70 {lab=vgn2}
N 1740 -520 1740 -500 {lab=vgp}
N 1740 250 1810 250 {lab=avss}
N 1130 250 1230 250 {lab=avss}
N 1570 -700 1660 -700 {lab=vgp}
N 1740 -550 1740 -520 {lab=vgp}
N 1660 -700 1680 -700 {lab=vgp}
N 440 -760 530 -760 {lab=avdd}
N 900 -760 980 -760 {lab=avdd}
N 530 250 900 250 {lab=avss}
N 900 110 900 150 {lab=avss}
N 30 -760 110 -760 {lab=avdd}
N 110 250 210 250 {lab=avss}
N 110 -760 310 -760 {lab=avdd}
N 900 -670 980 -670 {lab=avdd}
N 30 -70 110 -70 {lab=vsua}
N 900 -200 900 50 {lab=vcasp}
N 1050 -70 1130 -70 {lab=vsu}
N 1610 -180 1610 -130 {lab=vgn1}
N 1530 -180 1610 -180 {lab=vgn1}
N 1530 -140 1530 -120 {lab=vgn1}
N 1530 -180 1530 -140 {lab=vgn1}
N 1530 -400 1530 -180 {lab=vgn1}
N 1530 -550 1530 -460 {lab=#net2}
N 1970 -300 2050 -300 {lab=vref}
N 1740 -410 1740 -340 {lab=psrg_m3_feed}
N 1740 -310 1790 -310 {lab=avss}
N 1650 -310 1700 -310 {lab=psrg_vnc}
N 1740 -280 1740 -100 {lab=psrg_m3_protected}
N 2100 -300 2100 -240 {lab=vref}
N 2050 -300 2100 -300 {lab=vref}
N 2100 -180 2100 250 {lab=avss}
N 2040 250 2100 250 {lab=avss}
N 2250 -180 2250 -160 {lab=avss}
N 2100 -160 2250 -160 {lab=avss}
N 2250 -300 2250 -240 {lab=vref}
N 2100 -300 2250 -300 {lab=vref}
N 2400 -180 2400 -160 {lab=avss}
N 2250 -160 2400 -160 {lab=avss}
N 2400 -300 2400 -240 {lab=vref}
N 2250 -300 2400 -300 {lab=vref}
N 2550 -180 2550 -160 {lab=avss}
N 2400 -160 2550 -160 {lab=avss}
N 2550 -300 2550 -240 {lab=vref}
N 2400 -300 2550 -300 {lab=vref}
N 2700 -180 2700 -160 {lab=avss}
N 2550 -160 2700 -160 {lab=avss}
N 2700 -300 2700 -240 {lab=vref}
N 2550 -300 2700 -300 {lab=vref}
N 2850 -180 2850 -160 {lab=avss}
N 2700 -160 2850 -160 {lab=avss}
N 2850 -300 2850 -240 {lab=vref}
N 2700 -300 2850 -300 {lab=vref}
N 3000 -180 3000 -160 {lab=avss}
N 2850 -160 3000 -160 {lab=avss}
N 3000 -300 3000 -240 {lab=vref}
N 2850 -300 3000 -300 {lab=vref}
N 3150 -180 3150 -160 {lab=avss}
N 3000 -160 3150 -160 {lab=avss}
N 3150 -300 3150 -240 {lab=vref}
N 3000 -300 3150 -300 {lab=vref}
N 3300 -180 3300 -160 {lab=avss}
N 3150 -160 3300 -160 {lab=avss}
N 3300 -300 3300 -240 {lab=vref}
N 3150 -300 3300 -300 {lab=vref}
N 3450 -180 3450 -160 {lab=avss}
N 3300 -160 3450 -160 {lab=avss}
N 3450 -300 3450 -240 {lab=vref}
N 3300 -300 3450 -300 {lab=vref}
N -10 -760 30 -760 {lab=avdd}
N 20 250 110 250 {lab=avss}
N 820 1230 890 1230 {lab=avdd}
N 710 1230 780 1230 {lab=vbp_tail}
N 710 1260 710 1290 {lab=vsp}
N 930 1260 930 1290 {lab=vsp}
N 710 1260 930 1260 {lab=vsp}
N 710 1320 770 1320 {lab=avdd}
N 870 1320 930 1320 {lab=avdd}
N 630 1320 670 1320 {lab=v1}
N 970 1320 1010 1320 {lab=v2}
N 1120 1520 1120 1540 {lab=xf1}
N 1160 1460 1330 1460 {lab=vbn_fold}
N 1160 1570 1330 1570 {lab=vbn_sink}
N 1370 1500 1370 1540 {lab=xf2}
N 1030 1570 1120 1570 {lab=avss}
N 1030 1570 1030 1630 {lab=avss}
N 1370 1630 1460 1630 {lab=avss}
N 1460 1570 1460 1630 {lab=avss}
N 1370 1570 1460 1570 {lab=avss}
N 1370 1600 1370 1630 {lab=avss}
N 1120 1600 1120 1630 {lab=avss}
N 1030 1460 1120 1460 {lab=avss}
N 1370 1460 1460 1460 {lab=avss}
N 710 1350 710 1520 {lab=xf1}
N 710 1520 1120 1520 {lab=xf1}
N 930 1350 930 1500 {lab=xf2}
N 930 1500 1370 1500 {lab=xf2}
N 1120 1210 1120 1270 {lab=pm1}
N 1370 1210 1370 1270 {lab=pm2}
N 1370 1330 1370 1430 {lab=vgn2}
N 1160 1300 1330 1300 {lab=vbp_cas}
N 1210 1180 1330 1180 {lab=y1}
N 1370 1120 1370 1150 {lab=avdd}
N 1120 1120 1370 1120 {lab=avdd}
N 1120 1120 1120 1150 {lab=avdd}
N 1070 1300 1120 1300 {lab=avdd}
N 1080 1180 1120 1180 {lab=avdd}
N 1370 1180 1430 1180 {lab=avdd}
N 1370 1300 1430 1300 {lab=avdd}
N 820 1120 820 1200 {lab=avdd}
N 890 1120 1120 1120 {lab=avdd}
N 1210 1180 1210 1350 {lab=y1}
N 890 1120 890 1230 {lab=avdd}
N 1120 1350 1210 1350 {lab=y1}
N 1560 450 1560 520 {lab=avdd}
N 1490 550 1560 550 {lab=avdd}
N 1490 450 1490 550 {lab=avdd}
N 1490 450 1560 450 {lab=avdd}
N 1560 580 1560 630 {lab=vbp_tail}
N 1560 630 1630 630 {lab=vbp_tail}
N 1630 550 1630 630 {lab=vbp_tail}
N 1600 550 1630 550 {lab=vbp_tail}
N 1560 630 1560 900 {lab=vbp_tail}
N 1560 960 1560 1020 {lab=avss}
N 1890 930 1890 1020 {lab=avss}
N 1840 900 1890 900 {lab=avss}
N 1840 900 1840 1020 {lab=avss}
N 1890 610 1890 820 {lab=vbn_sink}
N 1890 450 1890 550 {lab=avdd}
N 1820 450 1890 450 {lab=avdd}
N 1930 900 1980 900 {lab=vbn_sink}
N 1980 820 1980 900 {lab=vbn_sink}
N 1890 820 1980 820 {lab=vbn_sink}
N 1890 820 1890 870 {lab=vbn_sink}
N 2100 580 2100 610 {lab=vbn_fold}
N 2100 580 2200 580 {lab=vbn_fold}
N 2200 580 2200 640 {lab=vbn_fold}
N 2140 640 2200 640 {lab=vbn_fold}
N 2030 640 2100 640 {lab=avss}
N 2100 560 2100 580 {lab=vbn_fold}
N 2100 450 2100 500 {lab=avdd}
N 2020 450 2100 450 {lab=avdd}
N 2140 760 2200 760 {lab=vnx_bias}
N 2030 760 2100 760 {lab=avss}
N 2100 690 2100 730 {lab=vnx_bias}
N 2100 690 2200 690 {lab=vnx_bias}
N 2200 690 2200 760 {lab=vnx_bias}
N 2100 790 2100 1020 {lab=avss}
N 1890 1020 2100 1020 {lab=avss}
N 2370 980 2370 1020 {lab=avss}
N 2370 870 2370 920 {lab=vbp_cas}
N 2100 1020 2370 1020 {lab=avss}
N 2300 790 2370 790 {lab=avdd}
N 2370 820 2370 870 {lab=vbp_cas}
N 2410 790 2440 790 {lab=vbp_cas}
N 2300 590 2370 590 {lab=avdd}
N 2370 660 2370 760 {lab=vbp_bias}
N 2410 590 2440 590 {lab=vbp_bias}
N 2300 450 2370 450 {lab=avdd}
N 2370 450 2370 560 {lab=avdd}
N 2370 870 2440 870 {lab=vbp_cas}
N 2440 790 2440 870 {lab=vbp_cas}
N 2370 660 2440 660 {lab=vbp_bias}
N 2440 590 2440 660 {lab=vbp_bias}
N 2300 590 2300 790 {lab=avdd}
N 2300 450 2300 590 {lab=avdd}
N 1650 930 1650 1020 {lab=avss}
N 1560 930 1650 930 {lab=avss}
N 1470 930 1520 930 {lab=vbn_i}
N 2370 1020 2460 1020 {lab=avss}
N 2460 950 2460 1020 {lab=avss}
N 2370 950 2460 950 {lab=avss}
N 2290 950 2330 950 {lab=vbn_i}
N 1820 580 1890 580 {lab=avdd}
N 1820 450 1820 580 {lab=avdd}
N 1930 580 1990 580 {lab=vbp_i}
N 2020 530 2100 530 {lab=avdd}
N 2020 450 2020 530 {lab=avdd}
N 2140 530 2190 530 {lab=vbp_i}
N 1020 510 1110 510 {lab=avdd}
N 1020 450 1020 510 {lab=avdd}
N 1120 1630 1370 1630 {lab=avss}
N 1030 1630 1120 1630 {lab=avss}
N 1120 1490 1120 1520 {lab=xf1}
N 1370 1490 1370 1500 {lab=xf2}
N 1160 1180 1210 1180 {lab=y1}
N 820 1120 890 1120 {lab=avdd}
N 1120 1330 1120 1350 {lab=y1}
N 1840 1020 1890 1020 {lab=avss}
N 1770 1020 1840 1020 {lab=avss}
N 2100 670 2100 690 {lab=vnx_bias}
N 2370 620 2370 660 {lab=vbp_bias}
N 2100 450 2300 450 {lab=avdd}
N 1270 1020 1560 1020 {lab=avss}
N 1560 1020 1650 1020 {lab=avss}
N 1680 450 1820 450 {lab=avdd}
N 1890 450 2020 450 {lab=avdd}
N 1340 450 1490 450 {lab=avdd}
N 1110 450 1110 480 {lab=avdd}
N 1270 450 1270 480 {lab=avdd}
N 1200 510 1230 510 {lab=vbp_i}
N 1180 670 1230 670 {lab=vbn_i}
N 1060 670 1110 670 {lab=avss}
N 1270 670 1320 670 {lab=avss}
N 1200 580 1270 580 {lab=vbp_i}
N 1200 510 1200 580 {lab=vbp_i}
N 1110 700 1110 1020 {lab=avss}
N 1110 1020 1270 1020 {lab=avss}
N 1020 450 1110 450 {lab=avdd}
N 1110 450 1270 450 {lab=avdd}
N 1150 670 1180 670 {lab=vbn_i}
N 1270 540 1270 580 {lab=vbp_i}
N 1150 510 1200 510 {lab=vbp_i}
N 1110 610 1110 630 {lab=vbn_i}
N 1270 510 1340 510 {lab=avdd}
N 1340 450 1340 510 {lab=avdd}
N 1110 630 1110 640 {lab=vbn_i}
N 1270 580 1270 640 {lab=vbp_i}
N 1270 980 1270 1020 {lab=avss}
N 1270 890 1270 920 {lab=#net3}
N 1230 860 1250 860 {lab=avss}
N 1230 950 1250 950 {lab=avdd}
N 1180 610 1180 670 {lab=vbn_i}
N 1110 610 1180 610 {lab=vbn_i}
N 1270 700 1270 760 {lab=vrs}
N 1270 820 1270 830 {lab=#net4}
N 600 800 600 830 {lab=vsu1}
N 600 890 600 920 {lab=vsu2}
N 600 1020 1000 1020 {lab=avss}
N 600 980 600 1020 {lab=avss}
N 560 950 600 950 {lab=avss}
N 560 950 560 1020 {lab=avss}
N 560 1020 600 1020 {lab=avss}
N 560 860 560 950 {lab=avss}
N 560 860 600 860 {lab=avss}
N 860 450 910 450 {lab=avdd}
N 640 860 670 860 {lab=vbp_i}
N 640 950 670 950 {lab=vbp_i}
N 1040 630 1110 630 {lab=vbn_i}
N 1270 450 1340 450 {lab=avdd}
N 1110 540 1110 610 {lab=vbn_i}
N 800 450 860 450 {lab=avdd}
N 1120 1380 1140 1380 {lab=avss}
N 1120 1410 1120 1430 {lab=psrg_mf1_protected}
N 1030 1380 1080 1380 {lab=psrg_vnc}
N 290 740 320 740 {lab=psrg_vnc}
N 290 640 290 740 {lab=psrg_vnc}
N 290 640 360 640 {lab=psrg_vnc}
N 360 770 360 940 {lab=rb_mid}
N 290 970 320 970 {lab=rb_mid}
N 290 870 290 970 {lab=rb_mid}
N 290 870 360 870 {lab=rb_mid}
N 1370 1390 1570 1390 {lab=vgn2}
N 1570 1390 1570 1440 {lab=vgn2}
N 1570 1500 1570 1630 {lab=avss}
N 1460 1630 1570 1630 {lab=avss}
N 1400 690 1400 720 {lab=su_state}
N 1440 660 1480 660 {lab=vbp_tail}
N 1400 600 1400 630 {lab=avdd}
N 1360 660 1400 660 {lab=avdd}
N 1720 700 1720 730 {lab=su_state}
N 1640 670 1680 670 {lab=vsu}
N 1720 610 1720 640 {lab=avdd}
N 1720 670 1760 670 {lab=avdd}
N 1400 770 1400 800 {lab=su_state}
N 1440 830 1480 830 {lab=vgn2}
N 1400 860 1400 890 {lab=avss}
N 1360 830 1400 830 {lab=avss}
N 360 740 470 740 {lab=avss}
N 360 1000 360 1020 {lab=avss}
N 360 970 430 970 {lab=avss}
N 430 970 430 1020 {lab=avss}
N 1400 720 1400 770 {lab=su_state}
N 1400 450 1400 600 {lab=avdd}
N 1400 890 1400 1020 {lab=avss}
N 1480 660 1560 660 {lab=vbp_tail}
N 910 450 1010 450 {lab=avdd}
N 1010 450 1020 450 {lab=avdd}
N 1000 1020 1110 1020 {lab=avss}
N 1610 670 1640 670 {lab=vsu}
N 3450 -300 3480 -300 {lab=vref}
N 380 -400 380 -330 {lab=vbn}
N 380 -530 380 -460 {lab=avdd}
N 420 510 500 510 {lab=vbp_i}
N 600 650 600 670 {lab=iref_gate}
N 640 700 720 700 {lab=vbp_i}
N 600 730 600 800 {lab=vsu1}
N 650 580 730 580 {lab=iref_gate}
N 770 480 770 550 {lab=avdd}
N 1280 -220 1280 -150 {lab=vgn1}
N 1160 -250 1240 -250 {lab=aux_gate}
N 1280 -350 1280 -280 {lab=vgp}
N 280 -660 280 -590 {lab=aux_gate}
N 920 700 920 770 {lab=aux_gate}
N 960 800 1040 800 {lab=vbn_i}
N 920 830 920 900 {lab=avss}
N 280 -690 330 -690 {lab=avdd}
N 330 -760 330 -690 {lab=avdd}
N 280 -760 280 -720 {lab=avdd}
N 560 700 600 700 {lab=avss}
N 600 580 650 580 {lab=iref_gate}
N 600 580 600 650 {lab=iref_gate}
N 770 450 770 480 {lab=avdd}
N 770 580 830 580 {lab=avdd}
N 830 450 830 580 {lab=avdd}
N 770 630 980 630 {lab=net5}
N 770 610 770 630 {lab=net5}
N 360 1020 560 1020 {lab=avss}
N 1560 450 1680 450 {lab=avdd}
N 1650 1020 1770 1020 {lab=avss}
N 1720 460 1720 610 {lab=avdd}
N 1720 450 1720 460 {lab=avdd}
N 1400 730 1720 730 {lab=su_state}
N 360 -760 440 -760 {lab=avdd}
N 450 250 530 250 {lab=avss}
N 280 -430 340 -430 {lab=aux_gate}
N 280 -590 280 -430 {lab=aux_gate}
N 380 -760 380 -530 {lab=avdd}
N 380 -430 450 -430 {lab=avdd}
N 1280 -150 1530 -150 {lab=vgn1}
N 1280 -690 1280 -350 {lab=vgp}
N 920 900 920 1020 {lab=avss}
N 840 800 920 800 {lab=avss}
N 840 800 840 870 {lab=avss}
N 840 870 920 870 {lab=avss}
N 380 -330 380 -260 {lab=vbn}
N 380 -260 530 -260 {lab=vbn}
N 540 450 540 480 {lab=avdd}
N 540 510 620 510 {lab=avdd}
N 620 450 620 510 {lab=avdd}
N 540 540 540 610 {lab=iref_gate}
N 360 450 800 450 {lab=avdd}
N 360 450 360 480 {lab=avdd}
N 540 610 600 610 {lab=iref_gate}
N 360 540 360 710 {lab=psrg_vnc}
N 400 510 420 510 {lab=vbp_i}
N 290 510 360 510 {lab=avdd}
N 290 450 290 510 {lab=avdd}
N 290 450 360 450 {lab=avdd}
N 1280 -250 1360 -250 {lab=avdd}
N 2880 272.5 2880 292.5 {lab=rbit0top}
N 2880 432.5 2880 452.5 {lab=rbit2top}
N 2880 512.5 2880 532.5 {lab=rbit3top}
N 2880 592.5 2880 612.5 {lab=rbit4top}
N 2880 672.5 2880 692.5 {lab=rbit5top}
N 2880 752.5 2880 772.5 {lab=rbit6top}
N 2770 512.5 2770 772.5 {lab=#net6}
N 2820 722.5 2860 722.5 {lab=avss}
N 2820 642.5 2860 642.5 {lab=avss}
N 2820 562.5 2860 562.5 {lab=avss}
N 2830 -7.5 2860 -7.5 {lab=avss}
N 2830 322.5 2860 322.5 {lab=avss}
N 2830 402.5 2860 402.5 {lab=avss}
N 2820 482.5 2860 482.5 {lab=avss}
N 2820 402.5 2830 402.5 {lab=avss}
N 2820 322.5 2830 322.5 {lab=avss}
N 2820 -7.5 2830 -7.5 {lab=avss}
N 2880 352.5 2880 372.5 {lab=rbit1top}
N 2880 832.5 2880 852.5 {lab=#net6}
N 2820 802.5 2860 802.5 {lab=avss}
N 2770 772.5 2770 852.5 {lab=#net6}
N 2770 852.5 2880 852.5 {lab=#net6}
N 2830 72.5 2860 72.5 {lab=avss}
N 2820 72.5 2830 72.5 {lab=avss}
N 2830 152.5 2860 152.5 {lab=avss}
N 2820 152.5 2830 152.5 {lab=avss}
N 2830 232.5 2860 232.5 {lab=avss}
N 2820 232.5 2830 232.5 {lab=avss}
N 2880 22.5 2880 42.5 {lab=rfix0}
N 2880 102.5 2880 122.5 {lab=rfix1}
N 2880 182.5 2880 202.5 {lab=rfix2}
N 2880 262.5 2880 272.5 {lab=rbit0top}
N 2770 222.5 2770 512.5 {lab=#net6}
N 2660 200 2770 200 {lab=#net6}
N 3070 342.5 3070 352.5 {lab=rbit1top}
N 3070 362.5 3210 362.5 {lab=rbit1top}
N 3070 272.5 3070 282.5 {lab=rbit0top}
N 3070 272.5 3210 272.5 {lab=rbit0top}
N 3300 342.5 3300 352.5 {lab=rbit1top}
N 3300 272.5 3300 282.5 {lab=rbit0top}
N 3210 272.5 3300 272.5 {lab=rbit0top}
N 3070 352.5 3070 362.5 {lab=rbit1top}
N 2880 362.5 3070 362.5 {lab=rbit1top}
N 2880 272.5 3070 272.5 {lab=rbit0top}
N 3210 362.5 3300 362.5 {lab=rbit1top}
N 3300 352.5 3300 362.5 {lab=rbit1top}
N 3060 362.5 3060 372.5 {lab=rbit1top}
N 3060 432.5 3060 442.5 {lab=rbit2top}
N 2880 442.5 3060 442.5 {lab=rbit2top}
N 3060 442.5 3290 442.5 {lab=rbit2top}
N 3290 432.5 3290 442.5 {lab=rbit2top}
N 3290 362.5 3290 372.5 {lab=rbit1top}
N 3070 442.5 3070 452.5 {lab=rbit2top}
N 3070 512.5 3070 522.5 {lab=rbit3top}
N 2880 522.5 3070 522.5 {lab=rbit3top}
N 3070 522.5 3300 522.5 {lab=rbit3top}
N 3300 512.5 3300 522.5 {lab=rbit3top}
N 3300 442.5 3300 452.5 {lab=rbit2top}
N 3290 442.5 3300 442.5 {lab=rbit2top}
N 3060 522.5 3060 532.5 {lab=rbit3top}
N 3290 522.5 3290 532.5 {lab=rbit3top}
N 3060 592.5 3060 602.5 {lab=rbit4top}
N 2880 602.5 3060 602.5 {lab=rbit4top}
N 3060 602.5 3290 602.5 {lab=rbit4top}
N 3290 592.5 3290 602.5 {lab=rbit4top}
N 3070 602.5 3070 612.5 {lab=rbit4top}
N 3300 602.5 3300 612.5 {lab=rbit4top}
N 3290 602.5 3300 602.5 {lab=rbit4top}
N 3070 672.5 3070 682.5 {lab=rbit5top}
N 2880 682.5 3070 682.5 {lab=rbit5top}
N 3070 682.5 3300 682.5 {lab=rbit5top}
N 3300 672.5 3300 682.5 {lab=rbit5top}
N 2880 762.5 3060 762.5 {lab=rbit6top}
N 3060 752.5 3060 762.5 {lab=rbit6top}
N 3290 752.5 3290 762.5 {lab=rbit6top}
N 3060 762.5 3290 762.5 {lab=rbit6top}
N 3060 682.5 3060 692.5 {lab=rbit5top}
N 3290 682.5 3290 692.5 {lab=rbit5top}
N 2880 852.5 3300 852.5 {lab=#net6}
N 3300 832.5 3300 852.5 {lab=#net6}
N 3070 832.5 3070 852.5 {lab=#net6}
N 3070 762.5 3070 772.5 {lab=rbit6top}
N 3300 762.5 3300 772.5 {lab=rbit6top}
N 3290 762.5 3300 762.5 {lab=rbit6top}
N 3010 312.5 3030 312.5 {lab=b0}
N 3000 402.5 3020 402.5 {lab=b1}
N 3340 312.5 3360 312.5 {lab=#net7}
N 3330 402.5 3350 402.5 {lab=b1_b}
N 3340 482.5 3360 482.5 {lab=#net8}
N 3010 482.5 3030 482.5 {lab=b2}
N 3000 562.5 3020 562.5 {lab=b3}
N 3010 642.5 3030 642.5 {lab=b4}
N 3000 722.5 3020 722.5 {lab=b5}
N 3010 802.5 3030 802.5 {lab=b6}
N 3330 562.5 3350 562.5 {lab=b3_b}
N 3340 642.5 3360 642.5 {lab=#net9}
N 3330 722.5 3350 722.5 {lab=b5_b}
N 3340 802.5 3360 802.5 {lab=#net10}
N 3070 312.5 3105 312.5 {lab=avss}
N 3060 402.5 3100 402.5 {lab=avss}
N 3070 482.5 3105 482.5 {lab=avss}
N 3060 562.5 3095 562.5 {lab=avss}
N 3070 642.5 3100 642.5 {lab=avss}
N 3055 722.5 3095 722.5 {lab=avss}
N 3070 802.5 3105 802.5 {lab=avss}
N 3265 312.5 3300 312.5 {lab=avdd}
N 3260 402.5 3295 402.5 {lab=avdd}
N 3275 482.5 3305 482.5 {lab=avdd}
N 3270 482.5 3275 482.5 {lab=avdd}
N 3260 562.5 3290 562.5 {lab=avdd}
N 3265 642.5 3300 642.5 {lab=avdd}
N 3255 722.5 3290 722.5 {lab=avdd}
N 3260 802.5 3305 802.5 {lab=avdd}
N 2660 -60 2880 -60 {lab=vref}
N 2880 -60 2880 -37.5 {lab=vref}
N 3455 65 3455 105 {lab=b0_b}
N 3455 165 3455 195 {lab=dvss}
N 3455 195 3500 195 {lab=dvss}
N 3500 135 3500 195 {lab=dvss}
N 3455 135 3500 135 {lab=dvss}
N 3455 35 3495 35 {lab=dvdd}
N 3495 -20 3495 35 {lab=dvdd}
N 3455 -20 3495 -20 {lab=dvdd}
N 3455 -20 3455 5 {lab=dvdd}
N 3390 135 3415 135 {lab=b0}
N 3390 35 3390 135 {lab=b0}
N 3390 35 3415 35 {lab=b0}
N 3355 80 3390 80 {lab=b0}
N 3455 80 3545 80 {lab=b0_b}
N 3685 65 3685 105 {lab=b1_b}
N 3685 165 3685 195 {lab=dvss}
N 3685 195 3730 195 {lab=dvss}
N 3730 135 3730 195 {lab=dvss}
N 3685 135 3730 135 {lab=dvss}
N 3685 35 3725 35 {lab=dvdd}
N 3725 -20 3725 35 {lab=dvdd}
N 3685 -20 3725 -20 {lab=dvdd}
N 3685 -20 3685 5 {lab=dvdd}
N 3620 135 3645 135 {lab=b1}
N 3620 35 3620 135 {lab=b1}
N 3620 35 3645 35 {lab=b1}
N 3585 80 3620 80 {lab=b1}
N 3685 80 3775 80 {lab=b1_b}
N 3920 65 3920 105 {lab=b2_b}
N 3920 165 3920 195 {lab=dvss}
N 3920 195 3965 195 {lab=dvss}
N 3965 135 3965 195 {lab=dvss}
N 3920 135 3965 135 {lab=dvss}
N 3920 35 3960 35 {lab=dvdd}
N 3960 -20 3960 35 {lab=dvdd}
N 3920 -20 3960 -20 {lab=dvdd}
N 3920 -20 3920 5 {lab=dvdd}
N 3855 135 3880 135 {lab=b2}
N 3855 35 3855 135 {lab=b2}
N 3855 35 3880 35 {lab=b2}
N 3820 80 3855 80 {lab=b2}
N 3920 80 4010 80 {lab=b2_b}
N 4140 65 4140 105 {lab=b3_b}
N 4140 165 4140 195 {lab=dvss}
N 4140 195 4185 195 {lab=dvss}
N 4185 135 4185 195 {lab=dvss}
N 4140 135 4185 135 {lab=dvss}
N 4140 35 4180 35 {lab=dvdd}
N 4180 -20 4180 35 {lab=dvdd}
N 4140 -20 4180 -20 {lab=dvdd}
N 4140 -20 4140 5 {lab=dvdd}
N 4075 135 4100 135 {lab=b3}
N 4075 35 4075 135 {lab=b3}
N 4075 35 4100 35 {lab=b3}
N 4040 80 4075 80 {lab=b3}
N 4140 80 4230 80 {lab=b3_b}
N 4360 65 4360 105 {lab=b4_b}
N 4360 165 4360 195 {lab=dvss}
N 4360 195 4405 195 {lab=dvss}
N 4405 135 4405 195 {lab=dvss}
N 4360 135 4405 135 {lab=dvss}
N 4360 35 4400 35 {lab=dvdd}
N 4400 -20 4400 35 {lab=dvdd}
N 4360 -20 4400 -20 {lab=dvdd}
N 4360 -20 4360 5 {lab=dvdd}
N 4295 135 4320 135 {lab=b4}
N 4295 35 4295 135 {lab=b4}
N 4295 35 4320 35 {lab=b4}
N 4260 80 4295 80 {lab=b4}
N 4360 80 4450 80 {lab=b4_b}
N 4570 65 4570 105 {lab=b5_b}
N 4570 165 4570 195 {lab=dvss}
N 4570 195 4615 195 {lab=dvss}
N 4615 135 4615 195 {lab=dvss}
N 4570 135 4615 135 {lab=dvss}
N 4570 35 4610 35 {lab=dvdd}
N 4610 -20 4610 35 {lab=dvdd}
N 4570 -20 4610 -20 {lab=dvdd}
N 4570 -20 4570 5 {lab=dvdd}
N 4505 135 4530 135 {lab=b5}
N 4505 35 4505 135 {lab=b5}
N 4505 35 4530 35 {lab=b5}
N 4470 80 4505 80 {lab=b5}
N 4570 80 4660 80 {lab=b5_b}
N 4792.5 65 4792.5 105 {lab=b6_b}
N 4792.5 165 4792.5 195 {lab=dvss}
N 4792.5 195 4837.5 195 {lab=dvss}
N 4837.5 135 4837.5 195 {lab=dvss}
N 4792.5 135 4837.5 135 {lab=dvss}
N 4792.5 35 4832.5 35 {lab=dvdd}
N 4832.5 -20 4832.5 35 {lab=dvdd}
N 4792.5 -20 4832.5 -20 {lab=dvdd}
N 4792.5 -20 4792.5 5 {lab=dvdd}
N 4727.5 135 4752.5 135 {lab=b6}
N 4727.5 35 4727.5 135 {lab=b6}
N 4727.5 35 4752.5 35 {lab=b6}
N 4692.5 80 4727.5 80 {lab=b6}
N 4792.5 80 4882.5 80 {lab=b6_b}
N 2770 200 2770 222.5 {lab=#net6}
C {symbols/pnp_05p00x05p00.sym} 1990 190 0 1 {name=Q3
model=pnp_05p00x05p00
spiceprefix=X
m=1}
C {symbols/pnp_05p00x05p00.sym} 1760 190 0 1 {name=Q2
model=pnp_05p00x05p00
spiceprefix=X
m=8}
C {symbols/pnp_05p00x05p00.sym} 1510 190 0 0 {name=Q1
model=pnp_05p00x05p00
spiceprefix=X
m=1}
C {lab_wire.sym} 1500 -70 0 0 {name=p1 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 1800 -70 0 0 {name=p2 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 1640 250 0 0 {name=p3 sig_type=std_logic lab=avss
}
C {symbols/nfet_03v3.sym} 1110 90 0 0 {name=M9
L=2u
W=1u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1110 200 0 0 {name=M10
L=2u
W=1u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 1300 -760 0 0 {name=p4 sig_type=std_logic lab=avdd
}
C {symbols/ppolyf_u_1k.sym} 1740 100 0 0 {name=R1
W=4e-6
L=42.10e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_wire.sym} 1710 100 0 0 {name=p6 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 1650 -700 0 0 {name=p9 sig_type=std_logic lab=vgp
}
C {lab_wire.sym} 1610 -70 0 0 {name=p10 sig_type=std_logic lab=vgn1
}
C {lab_wire.sym} 1130 -590 0 0 {name=p11 sig_type=std_logic lab=vsu
}
C {lab_wire.sym} 1530 30 0 0 {name=p12 sig_type=std_logic lab=v1
}
C {lab_wire.sym} 1740 30 0 0 {name=p13 sig_type=std_logic lab=v2
}
C {lab_wire.sym} 1740 150 0 0 {name=p14 sig_type=std_logic lab=vq2
}
C {lab_wire.sym} 1970 150 0 0 {name=p17 sig_type=std_logic lab=vq3
}
C {vsource.sym} 1530 -430 0 0 {name=VI1 value=0 savecurrent=false}
C {vsource.sym} 1740 -440 0 0 {name=VI2 value=0 savecurrent=false}
C {vsource.sym} 1970 -440 0 0 {name=VI3 value=0 savecurrent=false}
C {lab_wire.sym} 1490 -580 0 0 {name=p18 sig_type=std_logic lab=avdd
}
C {lab_wire.sym} 1660 -580 0 0 {name=p19 sig_type=std_logic lab=vcasp}
C {lab_wire.sym} 1920 -580 0 0 {name=p20 sig_type=std_logic lab=vcasp}
C {lab_wire.sym} 1800 -580 0 0 {name=p23 sig_type=std_logic lab=avdd
}
C {lab_wire.sym} 1530 -620 0 0 {name=p24 sig_type=std_logic lab=vx1}
C {lab_wire.sym} 1740 -620 0 0 {name=p25 sig_type=std_logic lab=vx2}
C {lab_wire.sym} 1970 -620 0 0 {name=p26 sig_type=std_logic lab=vx3}
C {lab_wire.sym} 600 -10 0 0 {name=p21 sig_type=std_logic lab=vbn
}
C {lab_wire.sym} 790 -510 0 0 {name=p27 sig_type=std_logic lab=vcasp
}
C {lab_wire.sym} 600 -660 0 0 {name=p28 sig_type=std_logic lab=vgp
}
C {lab_wire.sym} 530 -570 0 0 {name=p22 sig_type=std_logic lab=vaux
}
C {symbols/nfet_03v3.sym} 90 90 0 0 {name=M22
L=2u
W=1u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 90 200 0 0 {name=M23
L=2u
W=1u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 110 -580 0 0 {name=p29 sig_type=std_logic lab=vsua}
C {lab_wire.sym} 500 80 0 0 {name=p30 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 220 -690 0 0 {name=p31 sig_type=std_logic lab=vcasp}
C {lab_wire.sym} 1690 -70 0 0 {name=p32 sig_type=std_logic lab=vgn2
}
C {symbols/pfet_05v0.sym} 1550 -580 0 1 {name=M11
L=4u
W=16.42u
nf=1
mult=5
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 1720 -580 0 0 {name=M12
L=4u
W=16.42u
nf=1
mult=5
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 1950 -580 0 0 {name=M13
L=4u
W=16.42u
nf=1
mult=5
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 1550 -70 0 1 {name=M4
L=4u
W=14.6u
nf=1
mult=2
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 1720 -70 0 0 {name=M3
L=4u
W=14.6u
nf=1
mult=2
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 550 80 0 1 {name=M16
L=4u
W=7.55u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 880 80 0 0 {name=M18
L=4u
W=7.55u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 550 -510 0 1 {name=M15
L=4u
W=16u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 880 -670 0 0 {name=M17
L=2u
W=0.9u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {lab_wire.sym} 1100 30 0 0 {name=p84 sig_type=std_logic lab=bgsu1
}
C {lab_wire.sym} 1100 140 0 0 {name=p85 sig_type=std_logic lab=bgsu2
}
C {lab_wire.sym} 80 30 0 0 {name=p86 sig_type=std_logic lab=auxsu1
}
C {lab_wire.sym} 90 140 0 0 {name=p87 sig_type=std_logic lab=auxsu2
}
C {symbols/pfet_05v0.sym} 1150 -690 0 1 {name=M6
L=2u
W=2u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 130 -690 0 1 {name=M19
L=2u
W=2u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 1110 -10 0 0 {name=M8
L=2u
W=1u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 90 -10 0 0 {name=M21
L=2u
W=1u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 1550 -700 0 1 {name=M2
L=2u
W=16.75u
nf=1
mult=6
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 1720 -700 0 0 {name=M1
L=2u
W=16.75u
nf=1
mult=6
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 1950 -700 0 0 {name=M5
L=2u
W=16.75u
nf=1
mult=6
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 550 -660 0 1 {name=M14
L=2u
W=10u
nf=1
mult=2
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 1720 -310 0 0 {name=M3C
L=4u
W=14.6u
nf=1
mult=2
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {lab_wire.sym} 1740 -360 0 0 {name=psrg5_label0 sig_type=std_logic lab=psrg_m3_feed}
C {lab_wire.sym} 1740 -210 0 0 {name=psrg5_label2 sig_type=std_logic lab=psrg_m3_protected}
C {lab_wire.sym} 1790 -310 0 0 {name=psrg5_label3 sig_type=std_logic lab=avss}
C {lab_wire.sym} 2040 -300 0 0 {name=p8 sig_type=std_logic lab=vref
}
C {lab_wire.sym} 1680 -310 0 0 {name=psrg4 sig_type=std_logic lab=psrg_vnc}
C {symbols/cap_mim_2f0fF.sym} 2100 -210 0 0 {name=C2
W=70.7e-6
L=70.7e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/cap_mim_2f0fF.sym} 2250 -210 0 0 {name=C3
W=70.7e-6
L=70.7e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/cap_mim_2f0fF.sym} 2400 -210 0 0 {name=C4
W=70.7e-6
L=70.7e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/cap_mim_2f0fF.sym} 2550 -210 0 0 {name=C5
W=70.7e-6
L=70.7e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/cap_mim_2f0fF.sym} 2700 -210 0 0 {name=C6
W=70.7e-6
L=70.7e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/cap_mim_2f0fF.sym} 2850 -210 0 0 {name=C7
W=70.7e-6
L=70.7e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/cap_mim_2f0fF.sym} 3000 -210 0 0 {name=C8
W=70.7e-6
L=70.7e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/cap_mim_2f0fF.sym} 3150 -210 0 0 {name=C9
W=70.7e-6
L=70.7e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/cap_mim_2f0fF.sym} 3300 -210 0 0 {name=C10
W=70.7e-6
L=70.7e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/cap_mim_2f0fF.sym} 3450 -210 0 0 {name=C11
W=70.7e-6
L=70.7e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {iopin.sym} -10 -760 0 1 {name=p15 lab=avdd
}
C {iopin.sym} 20 250 0 1 {name=p16 lab=avss
}
C {symbols/pfet_03v3.sym} 800 1230 0 0 {name=MTAIL
L=6u
W=28.91u
nf=1
mult=6
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 760 1230 0 0 {name=p35 sig_type=std_logic lab=vbp_tail
}
C {lab_wire.sym} 770 1320 0 0 {name=p36 sig_type=std_logic lab=avdd
}
C {lab_wire.sym} 910 1320 0 0 {name=p37 sig_type=std_logic lab=avdd
}
C {lab_wire.sym} 1260 1630 0 0 {name=p38 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 1070 1460 0 0 {name=p39 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 1450 1460 0 0 {name=p40 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 1260 1120 0 0 {name=p41 sig_type=std_logic lab=avdd
}
C {lab_wire.sym} 1110 1180 0 0 {name=p42 sig_type=std_logic lab=avdd
}
C {lab_wire.sym} 1420 1180 0 0 {name=p43 sig_type=std_logic lab=avdd
}
C {lab_wire.sym} 1280 1460 0 0 {name=p49 sig_type=std_logic lab=vbn_fold
}
C {lab_wire.sym} 1280 1570 0 0 {name=p50 sig_type=std_logic lab=vbn_sink
}
C {lab_wire.sym} 1270 1300 0 0 {name=p51 sig_type=std_logic lab=vbp_cas
}
C {lab_wire.sym} 770 1260 0 0 {name=p52 sig_type=std_logic lab=vsp
}
C {lab_wire.sym} 780 1520 0 0 {name=p53 sig_type=std_logic lab=xf1
}
C {lab_wire.sym} 980 1500 0 0 {name=p54 sig_type=std_logic lab=xf2
}
C {lab_wire.sym} 1160 1350 0 0 {name=p55 sig_type=std_logic lab=y1
}
C {lab_wire.sym} 1120 1250 0 0 {name=p56 sig_type=std_logic lab=pm1
}
C {lab_wire.sym} 1370 1250 0 0 {name=p57 sig_type=std_logic lab=pm2
}
C {lab_wire.sym} 1370 1380 0 0 {name=p58 sig_type=std_logic lab=vgn2
}
C {lab_wire.sym} 660 1320 0 0 {name=p59 sig_type=std_logic lab=v1
}
C {lab_wire.sym} 1000 1320 0 0 {name=p60 sig_type=std_logic lab=v2
}
C {lab_wire.sym} 1110 1300 0 0 {name=p61 sig_type=std_logic lab=avdd
}
C {lab_wire.sym} 1420 1300 0 0 {name=p62 sig_type=std_logic lab=avdd
}
C {lab_wire.sym} 1540 450 0 0 {name=p33 sig_type=std_logic lab=avdd
}
C {lab_wire.sym} 1830 1020 0 0 {name=p34 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 2070 640 0 0 {name=p44 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 2070 760 0 0 {name=p45 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 1560 800 0 0 {name=p48 sig_type=std_logic lab=vbp_tail
}
C {lab_wire.sym} 1970 820 0 0 {name=p63 sig_type=std_logic lab=vbn_sink
}
C {lab_wire.sym} 2200 580 0 0 {name=p64 sig_type=std_logic lab=vbn_fold
}
C {lab_wire.sym} 2190 690 0 0 {name=p65 sig_type=std_logic lab=vnx_bias
}
C {lab_wire.sym} 2440 870 0 0 {name=p46 sig_type=std_logic lab=vbp_cas
}
C {lab_wire.sym} 2440 660 0 0 {name=p47 sig_type=std_logic lab=vbp_bias
}
C {lab_wire.sym} 1510 930 0 0 {name=p68 sig_type=std_logic lab=vbn_i
}
C {lab_wire.sym} 2320 950 0 0 {name=p69 sig_type=std_logic lab=vbn_i
}
C {lab_wire.sym} 1990 580 0 0 {name=p70 sig_type=std_logic lab=vbp_i
}
C {lab_wire.sym} 2190 530 0 0 {name=p71 sig_type=std_logic lab=vbp_i
}
C {lab_wire.sym} 1270 740 0 0 {name=p73 sig_type=std_logic lab=vrs
}
C {lab_wire.sym} 1110 600 0 0 {name=p67 sig_type=std_logic lab=vbn_i
}
C {lab_wire.sym} 1270 580 0 0 {name=p66 sig_type=std_logic lab=vbp_i
}
C {lab_wire.sym} 1310 670 0 0 {name=p72 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 1100 670 0 0 {name=p74 sig_type=std_logic lab=avss
}
C {symbols/nwell.sym} 1270 860 0 0 {name=R3
W=2e-6
L=20.19e-6
model=nwell
spiceprefix=X
m=1}
C {symbols/pplus_u.sym} 1270 950 0 0 {name=R4
W=1e-6
L=232.53e-6
model=pplus_u
spiceprefix=X
m=1}
C {lab_wire.sym} 1240 860 0 0 {name=p75 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 1240 950 0 0 {name=p76 sig_type=std_logic lab=avdd
}
C {vsource.sym} 1270 790 0 0 {name=VSENSE value=0 savecurrent=false}
C {lab_wire.sym} 1630 670 0 1 {name=p77 sig_type=std_logic lab=vsu
}
C {lab_wire.sym} 600 820 0 0 {name=p78 sig_type=std_logic lab=vsu1
}
C {lab_wire.sym} 600 910 0 0 {name=p79 sig_type=std_logic lab=vsu2
}
C {lab_wire.sym} 670 860 0 0 {name=p82 sig_type=std_logic lab=vbp_i
}
C {lab_wire.sym} 670 950 0 0 {name=p83 sig_type=std_logic lab=vbp_i
}
C {vsource.sym} 1010 630 3 0 {name=VSTARTSENSE value=0 savecurrent=false}
C {symbols/pfet_05v0.sym} 1350 1300 0 0 {name=PCAS2
L=8u
W=22.21u
nf=1
mult=6
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 1140 1300 0 1 {name=PCAS1
L=8u
W=22.21u
nf=1
mult=6
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 950 1320 0 1 {name=MINN
L=4u
W=54.89u
nf=1
mult=5
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 690 1320 0 0 {name=MINP
L=4u
W=54.89u
nf=1
mult=5
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 1350 1460 0 0 {name=MFOLD2
L=6u
W=18.49u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 1140 1460 0 1 {name=MFOLD1
L=6u
W=18.49u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 1130 670 0 1 {name=N1
L=8u
W=7.78u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 1250 670 0 0 {name=N2
L=8u
W=9.13u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 1250 510 0 0 {name=PREF
L=8u
W=18.75u
nf=1
mult=5
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 1130 510 0 1 {name=PRMIR
L=8u
W=18.75u
nf=1
mult=5
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 1540 930 0 0 {name=NTAIL
L=8u
W=13.95u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 2350 950 0 0 {name=N3
L=8u
W=0.65u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 1910 580 0 1 {name=MPSINK
L=8u
W=18.95u
nf=1
mult=17
m=17
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 2120 530 0 1 {name=MPFOLD
L=8u
W=18.99u
nf=1
mult=12
m=12
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 2120 640 0 1 {name=VBNFOLDHIGH
L=6u
W=4.62u
nf=1
m=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 2390 790 0 1 {name=VBPCASLOW
L=8u
W=18.93u
nf=1
mult=10
m=10
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1580 550 0 1 {name=VBPTAIL
L=6u
W=13.75u
nf=1
mult=3
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2120 760 0 1 {name=VBNFOLDLOW
L=8u
W=1.62u
nf=1
m=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2390 590 0 1 {name=VBPCASHIGHER
L=8u
W=19.06u
nf=1
mult=9
m=9
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 620 860 0 1 {name=SUPN2
L=50u
W=0.5u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 620 950 0 1 {name=SUPN3
L=50u
W=0.5u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 1140 1180 0 1 {name=PLOAD1
L=4u
W=20.76u
nf=1
mult=6
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 1350 1180 0 0 {name=PLOAD2
L=4u
W=20.76u
nf=1
mult=6
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 1100 1380 0 0 {name=MFOLD1C
L=6u
W=18.49u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {lab_wire.sym} 1140 1380 0 0 {name=psrg5_label9 sig_type=std_logic lab=avss}
C {lab_wire.sym} 1120 1420 0 0 {name=psrg5_label10 sig_type=std_logic lab=psrg_mf1_protected}
C {lab_wire.sym} 1070 1380 0 0 {name=psrg1 sig_type=std_logic lab=psrg_vnc}
C {symbols/pfet_05v0.sym} 380 510 0 1 {name=RB_P
L=4u
W=17.74u
nf=1
mult=7
m=7
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 340 740 0 0 {name=RB_NU
L=20u
W=0.71u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 340 970 0 0 {name=RB_NL
L=20u
W=0.54u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {lab_wire.sym} 470 510 0 0 {name=rb_pg lab=vbp_i}
C {lab_wire.sym} 360 640 0 0 {name=rb_vnc lab=psrg_vnc}
C {lab_wire.sym} 470 740 0 0 {name=rb_nb1 lab=avss}
C {lab_wire.sym} 360 870 0 0 {name=rb_mid_label lab=rb_mid}
C {symbols/pfet_05v0.sym} 1420 660 0 1 {name=MSU_LOAD
W=1u L=8u nf=1 m=1 mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {lab_wire.sym} 1400 750 0 1 {name=MSU_LOAD_p0 lab=su_state}
C {lab_wire.sym} 1360 660 0 1 {name=MSU_LOAD_p3 lab=avdd}
C {symbols/pfet_05v0.sym} 1700 670 0 0 {name=MSU_HYS
W=1u L=8u nf=1 m=1 mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {lab_wire.sym} 1730 670 0 1 {name=MSU_HYS_p3 lab=avdd}
C {symbols/nfet_05v0.sym} 1420 830 0 1 {name=MSU_SENSE
W=4u L=1u nf=1 m=1 mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {lab_wire.sym} 1480 830 0 1 {name=MSU_SENSE_p1 lab=vgn2}
C {lab_wire.sym} 1360 830 0 1 {name=MSU_SENSE_p3 lab=avss}
C {symbols/cap_mim_2f0fF.sym} 1570 1470 0 0 {name=C1
W=59e-6
L=59e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {iopin.sym} 3480 -300 0 0 {name=p88 lab=vref
}
C {symbols/pfet_05v0.sym} 360 -430 0 0 {name=M20
L=8u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 520 510 0 0 {name=SUPPDET
L=1u
W=80u
nf=1
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'"
nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 620 700 0 1 {name=SUPN1
L=50u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {lab_pin.sym} 560 700 0 0 {name=repair_SUPN1_3 lab=avss}
C {symbols/pfet_05v0.sym} 750 580 0 0 {name=SUPINJ
L=8u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 1260 -250 0 0 {name=M7
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X}
C {symbols/nfet_05v0.sym} 1140 1570 0 1 {name=MSINK1
L=8u
W=16.34u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 1350 1570 0 0 {name=MSINK2
L=8u
W=16.34u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 1910 900 0 1 {name=VBNSINK
L=8u
W=12.31u
nf=1
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} 260 -690 0 0 {name=AP
L=10u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} 940 800 0 1 {name=AN
L=8u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'"
nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {lab_wire.sym} 720 700 0 0 {name=p5 sig_type=std_logic lab=vbp_i
}
C {lab_wire.sym} 600 650 0 0 {name=p80 sig_type=std_logic lab=iref_gate
}
C {lab_wire.sym} 930 630 0 0 {name=p81 sig_type=std_logic lab=net5
}
C {lab_wire.sym} 440 -430 0 0 {name=p89 sig_type=std_logic lab=avdd}
C {lab_wire.sym} 1220 -250 0 0 {name=p90 sig_type=std_logic lab=aux_gate}
C {lab_wire.sym} 280 -490 0 0 {name=p91 sig_type=std_logic lab=aux_gate}
C {lab_wire.sym} 920 730 0 0 {name=p92 sig_type=std_logic lab=aux_gate}
C {lab_wire.sym} 1020 800 0 0 {name=p93 sig_type=std_logic lab=vbn_i
}
C {lab_wire.sym} 1360 -250 0 0 {name=p94 sig_type=std_logic lab=avdd
}
C {lab_wire.sym} 2767.5 -60 0 0 {name=p7 sig_type=std_logic lab=vref
}
C {symbols/ppolyf_u_1k.sym} 2880 -7.5 0 0 {name=RFIXED
W=6.6e-6
L=128e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 2880 322.5 0 0 {name=RB0
W=6.6e-6
L=2e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 2880 402.5 0 0 {name=RB1
W=6.6e-6
L=4e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 2880 482.5 0 0 {name=RB2
W=6.6e-6
L=8e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 2880 562.5 0 0 {name=RB3
W=6.6e-6
L=16e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 2880 642.5 0 0 {name=RB4
W=6.6e-6
L=32e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k.sym} 2880 722.5 0 0 {name=RB5
W=6.6e-6
L=64e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_wire.sym} 2850 562.5 0 0 {name=p95 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 2850 642.5 0 0 {name=p96 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 2850 722.5 0 0 {name=p97 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 2850 482.5 0 0 {name=p98 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 2850 402.5 0 0 {name=p99 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 2850 322.5 0 0 {name=p100 sig_type=std_logic lab=avss
}
C {lab_wire.sym} 2850 -7.5 0 0 {name=p101 sig_type=std_logic lab=avss
}
C {symbols/ppolyf_u_1k.sym} 2880 802.5 0 0 {name=RB6
W=6.6e-6
L=128e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_wire.sym} 2850 802.5 0 0 {name=p102 sig_type=std_logic lab=avss
}
C {symbols/ppolyf_u_1k.sym} 2880 72.5 0 0 {name=RFIXED1
W=6.6e-6
L=128e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_wire.sym} 2850 72.5 0 0 {name=p103 sig_type=std_logic lab=avss
}
C {symbols/ppolyf_u_1k.sym} 2880 152.5 0 0 {name=RFIXED2
W=6.6e-6
L=128e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_wire.sym} 2850 152.5 0 0 {name=p104 sig_type=std_logic lab=avss
}
C {symbols/ppolyf_u_1k.sym} 2880 232.5 0 0 {name=RFIXED3
W=6.6e-6
L=128e-6
model=ppolyf_u_1k
spiceprefix=X
m=1}
C {lab_wire.sym} 2850 232.5 0 0 {name=p105 sig_type=std_logic lab=avss
}
C {symbols/pfet_03v3.sym} 3320 312.5 0 1 {name=M24
L=0.28u
W=40u
nf=1
mult=6
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3050 312.5 0 0 {name=M25
L=0.28u
W=40u
nf=1
mult=2
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3310 402.5 0 1 {name=M26
L=0.28u
W=40u
nf=1
mult=3
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3040 402.5 0 0 {name=M27
L=0.28u
W=40u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3320 482.5 0 1 {name=M28
L=0.28u
W=20u
nf=1
mult=3
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3050 482.5 0 0 {name=M29
L=0.28u
W=20u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3310 562.5 0 1 {name=M30
L=0.28u
W=30u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3040 562.5 0 0 {name=M31
L=0.28u
W=10u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3320 642.5 0 1 {name=M32
L=0.28u
W=15u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3050 642.5 0 0 {name=M33
L=0.28u
W=5u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3310 722.5 0 1 {name=M34
L=0.28u
W=7.5u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3040 722.5 0 0 {name=M35
L=0.28u
W=2.5u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3320 802.5 0 1 {name=M36
L=0.28u
W=3.75u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3050 802.5 0 0 {name=M37
L=0.28u
W=1.25u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3020 312.5 0 0 {name=p106 sig_type=std_logic lab=b0
}
C {lab_wire.sym} 3010 402.5 0 0 {name=p107 sig_type=std_logic lab=b1
}
C {lab_wire.sym} 3020 482.5 0 0 {name=p108 sig_type=std_logic lab=b2
}
C {lab_wire.sym} 3010 562.5 0 0 {name=p109 sig_type=std_logic lab=b3
}
C {lab_wire.sym} 3020 642.5 0 0 {name=p110 sig_type=std_logic lab=b4
}
C {lab_wire.sym} 3010 722.5 0 0 {name=p111 sig_type=std_logic lab=b5
}
C {lab_wire.sym} 3020 802.5 0 0 {name=p112 sig_type=std_logic lab=b6
}
C {lab_wire.sym} 3350 402.5 0 0 {name=p113 sig_type=std_logic lab=b1_b
}
C {lab_wire.sym} 3350 562.5 0 0 {name=p114 sig_type=std_logic lab=b3_b
}
C {lab_wire.sym} 3350 722.5 0 0 {name=p115 sig_type=std_logic lab=b5_b}
C {lab_wire.sym} 3105 312.5 0 0 {name=p117 sig_type=std_logic lab=dvss
}
C {lab_wire.sym} 3100 402.5 0 0 {name=p118 sig_type=std_logic lab=dvss
}
C {lab_wire.sym} 3105 482.5 0 0 {name=p119 sig_type=std_logic lab=dvss
}
C {lab_wire.sym} 3095 562.5 0 0 {name=p120 sig_type=std_logic lab=dvss
}
C {lab_wire.sym} 3100 642.5 0 0 {name=p121 sig_type=std_logic lab=dvss
}
C {lab_wire.sym} 3095 722.5 0 0 {name=p122 sig_type=std_logic lab=dvss
}
C {lab_wire.sym} 3105 802.5 0 0 {name=p123 sig_type=std_logic lab=dvss
}
C {lab_wire.sym} 3295 312.5 0 0 {name=p124 sig_type=std_logic lab=dvdd
}
C {lab_wire.sym} 3290 402.5 0 0 {name=p125 sig_type=std_logic lab=dvdd
}
C {lab_wire.sym} 3295 482.5 0 0 {name=p126 sig_type=std_logic lab=dvdd
}
C {lab_wire.sym} 3285 562.5 0 0 {name=p127 sig_type=std_logic lab=dvdd
}
C {lab_wire.sym} 3295 642.5 0 0 {name=p128 sig_type=std_logic lab=dvdd
}
C {lab_wire.sym} 3285 722.5 0 0 {name=p129 sig_type=std_logic lab=dvdd
}
C {lab_wire.sym} 3295 802.5 0 0 {name=p130 sig_type=std_logic lab=dvdd
}
C {lab_wire.sym} 2880 35 0 0 {name=p160 sig_type=std_logic lab=rfix0
}
C {lab_wire.sym} 2880 115 0 0 {name=p161 sig_type=std_logic lab=rfix1
}
C {lab_wire.sym} 2880 197.5 0 0 {name=p162 sig_type=std_logic lab=rfix2
}
C {lab_wire.sym} 3182.5 272.5 0 0 {name=p163 sig_type=std_logic lab=rbit0top

}
C {lab_wire.sym} 3185 362.5 0 0 {name=p164 sig_type=std_logic lab=rbit1top

}
C {lab_wire.sym} 3190 442.5 0 0 {name=p165 sig_type=std_logic lab=rbit2top

}
C {lab_wire.sym} 3190 522.5 0 0 {name=p166 sig_type=std_logic lab=rbit3top

}
C {lab_wire.sym} 3192.5 602.5 0 0 {name=p167 sig_type=std_logic lab=rbit4top

}
C {lab_wire.sym} 3192.5 682.5 0 0 {name=p168 sig_type=std_logic lab=rbit5top

}
C {lab_wire.sym} 3195 762.5 0 0 {name=p169 sig_type=std_logic lab=rbit6top

}
C {lab_wire.sym} 3495 195 0 0 {name=p131 sig_type=std_logic lab=dvss
}
C {symbols/nfet_03v3.sym} 3435 135 0 0 {name=M38
L=0.5u
W=1u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3435 35 0 0 {name=M39
L=0.5u
W=3u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3490 -20 0 0 {name=p133 sig_type=std_logic lab=dvdd
}
C {lab_wire.sym} 3375 80 0 0 {name=p134 sig_type=std_logic lab=b0
}
C {lab_wire.sym} 3540 80 0 0 {name=p135 sig_type=std_logic lab=b0_b
}
C {lab_wire.sym} 3725 195 0 0 {name=p136 sig_type=std_logic lab=dvss
}
C {symbols/nfet_03v3.sym} 3665 135 0 0 {name=M40
L=0.5u
W=1u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3665 35 0 0 {name=M41
L=0.5u
W=3u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3720 -20 0 0 {name=p137 sig_type=std_logic lab=dvdd
}
C {lab_wire.sym} 3605 80 0 0 {name=p138 sig_type=std_logic lab=b1
}
C {lab_wire.sym} 3770 80 0 0 {name=p139 sig_type=std_logic lab=b1_b
}
C {lab_wire.sym} 3960 195 0 0 {name=p140 sig_type=std_logic lab=dvss
}
C {symbols/nfet_03v3.sym} 3900 135 0 0 {name=M42
L=0.5u
W=1u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3900 35 0 0 {name=M43
L=0.5u
W=3u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3955 -20 0 0 {name=p141 sig_type=std_logic lab=dvdd
}
C {lab_wire.sym} 3840 80 0 0 {name=p142 sig_type=std_logic lab=b2
}
C {lab_wire.sym} 4005 80 0 0 {name=p143 sig_type=std_logic lab=b2_b
}
C {lab_wire.sym} 4180 195 0 0 {name=p144 sig_type=std_logic lab=dvss
}
C {symbols/nfet_03v3.sym} 4120 135 0 0 {name=M44
L=0.5u
W=1u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4120 35 0 0 {name=M45
L=0.5u
W=3u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4175 -20 0 0 {name=p145 sig_type=std_logic lab=dvdd
}
C {lab_wire.sym} 4060 80 0 0 {name=p146 sig_type=std_logic lab=b3
}
C {lab_wire.sym} 4225 80 0 0 {name=p147 sig_type=std_logic lab=b3_b}
C {lab_wire.sym} 4400 195 0 0 {name=p148 sig_type=std_logic lab=dvss
}
C {symbols/nfet_03v3.sym} 4340 135 0 0 {name=M46
L=0.5u
W=1u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4340 35 0 0 {name=M47
L=0.5u
W=3u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4395 -20 0 0 {name=p149 sig_type=std_logic lab=dvdd
}
C {lab_wire.sym} 4280 80 0 0 {name=p150 sig_type=std_logic lab=b4}
C {lab_wire.sym} 4445 80 0 0 {name=p151 sig_type=std_logic lab=b4_b}
C {lab_wire.sym} 4610 195 0 0 {name=p152 sig_type=std_logic lab=dvss
}
C {symbols/nfet_03v3.sym} 4550 135 0 0 {name=M48
L=0.5u
W=1u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4550 35 0 0 {name=M49
L=0.5u
W=3u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4605 -20 0 0 {name=p153 sig_type=std_logic lab=dvdd
}
C {lab_wire.sym} 4490 80 0 0 {name=p154 sig_type=std_logic lab=b5}
C {lab_wire.sym} 4655 80 0 0 {name=p155 sig_type=std_logic lab=b5_b}
C {lab_wire.sym} 4832.5 195 0 0 {name=p156 sig_type=std_logic lab=dvss
}
C {symbols/nfet_03v3.sym} 4772.5 135 0 0 {name=M50
L=0.5u
W=1u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4772.5 35 0 0 {name=M51
L=0.5u
W=3u
nf=1
mult=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4827.5 -20 0 0 {name=p157 sig_type=std_logic lab=dvdd
}
C {lab_wire.sym} 4712.5 80 0 0 {name=p158 sig_type=std_logic lab=b6}
C {lab_wire.sym} 4877.5 80 0 0 {name=p159 sig_type=std_logic lab=b6_b}
C {lab_wire.sym} 2725 200 0 0 {name=p116 sig_type=std_logic lab=vq3
}
C {iopin.sym} 3010 312.5 0 1 {name=p132 lab=b0
}
C {iopin.sym} 3000 402.5 0 1 {name=p170 lab=b1
}
C {iopin.sym} 3010 482.5 0 1 {name=p171 lab=b2
}
C {iopin.sym} 3000 562.5 0 1 {name=p172 lab=b3
}
C {iopin.sym} 3010 642.5 0 1 {name=p173 lab=b4
}
C {iopin.sym} 3000 722.5 0 1 {name=p174 lab=b5
}
C {iopin.sym} 3010 802.5 0 1 {name=p175 lab=b6
}
C {iopin.sym} 3455 192.5 0 1 {name=p176 lab=dvss
}
C {iopin.sym} 3455 -17.5 0 1 {name=p177 lab=dvdd
}
C {lab_wire.sym} 3360 312.5 0 0 {name=p178 sig_type=std_logic lab=b0_b
}
C {lab_wire.sym} 3360 482.5 0 0 {name=p179 sig_type=std_logic lab=b2_b
}
C {lab_wire.sym} 3360 642.5 0 0 {name=p180 sig_type=std_logic lab=b4_b
}
C {lab_wire.sym} 3360 802.5 0 0 {name=p181 sig_type=std_logic lab=b6_b
}
